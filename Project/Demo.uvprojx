# Keil uVision project Demo.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F102RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\CMSIS;..\Lib\inc;..\Lib\src;..\Startup;..\USER;..\uCOS-II\Ports;..\uCOS-II\Source;..\uCOS-II\Config;..\BSP;..\App;..\BSP\NRF24L01;..\BSP\EXTI;..\BSP\MPU9250;..\BSP\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group UCOSII-CORE
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORTS
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII-CONFIG
    ../uCOS-II/Config/: app_cfg.h os_cfg.h
  group BSP
    ../BSP/LED/: led.c
    ../BSP/MOTOR/: motor.c
    ../BSP/NRF24L01/: nrf24l01.c spi.c
    ../BSP/EXTI/: EXTI.c
    ../BSP/USART/: usart.c
    ../BSP/MPU9250/: mpu9250.c i2c.c
  group App
    ../App/: app_task.c fly_reg.c Quaternion.c DataProcess.c Control.c AHRS.c Attitude.c Timer.c debug.c
    ../App/RC/: rc.c
